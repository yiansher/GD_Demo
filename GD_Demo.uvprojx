# Keil uVision project GD_Demo.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD_Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG_ENABLE_SEMIHOST
  c include: .\mdk;.\mdk\CMSIS;.\mdk\GD32F10x_standard_peripheral\Include;.\app;.\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./app/: main.c gd32f10x_it.c app_uart.c app_timer.c
  group hal
    ./hal/: hal_init.c hal_gpio.c
  group mdk
    ./mdk/: system_gd32f10x.c
    ./mdk/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
    ./mdk/GD32F10x_standard_peripheral/Source/: gd32f10x_dma.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_spi.c gd32f10x_usart.c
